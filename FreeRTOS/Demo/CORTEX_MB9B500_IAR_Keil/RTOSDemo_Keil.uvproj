# Keil uVision project RTOSDemo_Keil.uvproj, settings and files
target Blinky (ARM-ADS)
  device: MB9BF506N Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0007FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo_Keil
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\CORTEX_MB9B500_IAR_Keil;.\Fujitu_source;..\Common\include;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  group Fujitsu Source
    ./Fujitu_source/: system_mb9bf50x.c core_cm3.c
    ./Fujitu_source/startup_keil/: startup_mb9bf50x.s
  group Common_Demo_Source
    ../Common/Minimal/: TimerDemo.c BlockQ.c blocktim.c comtest.c countsem.c death.c dynamic.c flash.c GenQTest.c PollQ.c QPeek.c recmutex.c semtest.c
  group FreeRTOS_Source
    ../../Source/: timers.c list.c queue.c tasks.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
    ../../Source/portable/MemMang/: heap_2.c
  group Demo_Source
    ./: serial.c main_blinky.c main-full.c ParTest.c
target Full (ARM-ADS)
  device: MB9BF506N Fujitsu Semiconductors
  cpu: as above
  output: RTOSDemo_Keil
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
target Full_with_optimisation (ARM-ADS)
  device: MB9BF506N Fujitsu Semiconductors
  cpu: as above
  output: RTOSDemo_Keil
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
